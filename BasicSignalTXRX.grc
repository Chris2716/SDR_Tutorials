options:
  parameters:
    author: ucanlab
    generate_options: qt_gui
    id: Video1
    output_language: python
    title: 'Intro into SDR: USRP'
  states: {}

blocks:
- name: interp
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.25'
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: note_1
  id: note
  parameters:
    note: Real Sinusoid
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Transmitter
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '915000000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '915000000'
    dev_addr: '"serial=3279417"'
    dev_args: '""'
    gain0: '35'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '915000000'
    dc_offs_enb0: '""'
    dev_addr: '"serial=3279500"'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_1, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
